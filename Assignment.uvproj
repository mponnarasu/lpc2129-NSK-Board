# Keil uVision project Assignment.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Assignment +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s Lcd.h Main.c Retarget.c schedule.c schedule.h tasks.h Board.c LCD_Api.c Input_process.c SevenSeg_Api.c data_process.c output_process.c global_data.c global_data.h SevenSeg.h
